Commit message: 

File: example_robot.urdf.xacro (robot description, xacro)
@@ -44,5 +44,4 @@
         </visual>
     </link>
-    <!-- <joint name="l3_to_l2" type="fixed"> -->
     <joint name="l3_to_l2" type="revolute">
         <parent link="l3" />
